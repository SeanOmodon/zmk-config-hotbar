## boards/shields/hotbar/Kconfig.defconfig
```kconfig
if SHIELD_HOTBAR

config ZMK_KEYBOARD_NAME
    default "Hotbar"

endif # SHIELD_HOTBAR
```
